# IAR project Backup of sample.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F429ZI ST STM32F429ZI
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F429_439xx
  ICCARM.CCIncludePath2: C:\Program Files (x86)\IAR Systems\Libraries\CMSIS\Device\ST\STM32F4xx\Include; C:\Program Files (x86)\IAR Systems\Libraries\STM32F4xx_StdPeriph_Driver\inc; $PROJ_DIR$
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: sample.hex
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkIcfFile: stm32f429xG.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  group (top)
    ./: main.c
  group CMSIS
    ../../../../../Program Files (x86)/IAR Systems/Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f429_439xx.s
  group COMM
    ./: stm32f4xx_it.c system_stm32f4xx.c
  group STM32
    ../../../../../Program Files (x86)/IAR Systems/Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_gpio.c stm32f4xx_rcc.c
