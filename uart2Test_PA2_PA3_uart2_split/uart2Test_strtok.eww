<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\uart2Test_strtok.ewp</path>
    </project>
    <batchBuild />
</workspace>
