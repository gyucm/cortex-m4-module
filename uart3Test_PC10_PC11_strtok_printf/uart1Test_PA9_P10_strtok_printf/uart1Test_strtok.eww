<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\uart1Test_strtok.ewp</path>
    </project>
    <batchBuild />
</workspace>
